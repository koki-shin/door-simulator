Commit message: update 7/16

File: urdf/handle_door.urdf (robot description, URDF)
Before this commit: robot door_fixed, 5 links, 4 joints
Links:
- link door: mass 10 -> 15
Joints:
- joint hinge_joint: limit lower=-1 upper=1 effort=100 velocity=10 -> lower=-1.5 upper=0 effort=100 velocity=10
